# IAR project tmeter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x4 ST STM32F100x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ITMP_SERIAL_SLAVE_ADDRESS; ITMP_COUNTERS
  ICCARM.CCIncludePath2: nscduinolib\stm32f10x.core\; nscduinolib\stm32f10x.core\drivers; nscduinolib\; nscduinolib\lib\; $PROJ_DIR$; nscduinolib\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: tmeter.hex
  ILINK.IlinkOutputFile: mot823.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp
  group core
    nscduinolib/stm32f10x.core/: core_cm3.c startup_stm32f10x_ld_vl.s system_stm32f10x.c
  group drv
    drivers/: dma.c limb_driver.c ow.cpp
  group duino
    nscduinolib/lib/: crc.cpp
    nscduinolib/stm32f10x.core/drivers/: dac.cpp spi.cpp
    nscduinolib/drivers/: itmp.cpp itmp_serial.cpp pwm.cpp usart.cpp
  group duino_core
    nscduinolib/stm32f10x.core/drivers/: adc.cpp gpio-alloc.cpp sys.cpp tim.cpp
  group lpalg
    lpalg/: CBOR.cpp
